options:
  parameters:
    author: joao
    generate_options: qt_gui
    id: manual_beam_control
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rx_range
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '28'
    step: '1'
    stop: '36'
    value: '32'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: tx_range
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '28'
    step: '1'
    stop: '36'
    value: '32'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '200'
    type: byte
  states: {}
- name: center_freq
  id: parameter
  parameters:
    value: 5.3e9
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: '"packet_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: fft_len
  id: parameter
  parameters:
    type: intx
    value: '64'
  states: {}
- name: mmwave_beam_control_beam_mapper_0
  id: mmwave_beam_control_beam_mapper
  parameters:
    backoff: '2e-6'
    debug: 'True'
    pulse: '2e-6'
    rx_mhu: MHU2
    tx_mhu: MHU1
  states: {}
- name: mmwave_beam_control_manual_beam_0
  id: mmwave_beam_control_manual_beam
  parameters:
    debug: 'True'
    rx_beam: rx_range
    tx_beam: tx_range
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*2
    fc: center_freq
    fftsize: '1024'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: 2e6
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '0.700'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 0.5*samp_rate
    center_freq0: center_freq
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'True'
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: 0.5*samp_rate
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [mmwave_beam_control_beam_mapper_0, gpio_cmd, blocks_message_debug_0, print]
- [mmwave_beam_control_beam_mapper_0, gpio_cmd, uhd_usrp_sink_0_0, command]
- [mmwave_beam_control_manual_beam_0, beam_id, mmwave_beam_control_beam_mapper_0, beam_id]
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
