options:
  parameters:
    author: Dr. Joao Santos
    generate_options: qt_gui
    id: demo_initial_access
    output_language: python
    title: Commonwealth Cyber Initiative
  states: {}

blocks:
- name: beam
  id: variable_qtgui_range
  parameters:
    gui_hint: 'qtgui_tab_widget_0@0 : 0,0,1,2'
    label: Beam Period
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '0.100'
    value: '0.010'
  states: {}
- name: iadr
  id: variable_qtgui_range
  parameters:
    gui_hint: 'qtgui_tab_widget_0@0 : 1,0,1,2'
    label: IA Interval
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rx_beams
  id: variable
  parameters:
    value: range(rx_min, rx_max+1)
  states: {}
- name: rx_max
  id: variable_qtgui_range
  parameters:
    gui_hint: 'qtgui_tab_widget_0@0 : 3,1,1,1'
    label: RX End Beam
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '28'
    step: '1'
    stop: '36'
    value: '36'
  states: {}
- name: rx_min
  id: variable_qtgui_range
  parameters:
    gui_hint: 'qtgui_tab_widget_0@0 : 3,0,1,1'
    label: RX Start Beam
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '28'
    step: '1'
    stop: '36'
    value: '28'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: tx_beams
  id: variable
  parameters:
    value: range(tx_min, tx_max+1)
  states: {}
- name: tx_max
  id: variable_qtgui_range
  parameters:
    gui_hint: 'qtgui_tab_widget_0@0 : 2,1,1,1'
    label: TX End Beam
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '28'
    step: '1'
    stop: '36'
    value: '36'
  states: {}
- name: tx_min
  id: variable_qtgui_range
  parameters:
    gui_hint: 'qtgui_tab_widget_0@0 : 2,0,1,1'
    label: TX Start Beam
    min_len: '50'
    orient: Qt.Horizontal
    rangeType: int
    start: '28'
    step: '1'
    stop: '36'
    value: '28'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: beam_period
  id: parameter
  parameters:
    type: eng_float
    value: '0.05'
  states: {}
- name: blocks_ctrlport_monitor_0
  id: blocks_ctrlport_monitor
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '200'
    type: byte
  states: {}
- name: center_freq
  id: parameter
  parameters:
    value: 5.3e9
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: '"pdu_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: '"packet_len"'
    payload_mod: '"BPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: sync_word1
    sync_word2: sync_word2
  states: {}
- name: fft_len
  id: parameter
  parameters:
    type: intx
    value: '64'
  states: {}
- name: file_suffix
  id: parameter
  parameters:
    type: str
    value: demo
  states: {}
- name: ia_interval
  id: parameter
  parameters:
    type: eng_float
    value: '2'
  states: {}
- name: meas_period
  id: parameter
  parameters:
    type: eng_float
    value: '1e-3'
  states: {}
- name: mmwave_beam_control_beam_mapper_0
  id: mmwave_beam_control_beam_mapper
  parameters:
    backoff: '2e-6'
    config_path: /home/user/gr-mmwave_beam_control/examples/interdigital_mhuv3.json
    debug: 'True'
    pulse: '2e-6'
    rx_mhu: MHU2
    tx_mhu: MHU1
  states: {}
- name: mmwave_beam_control_beam_selector_0
  id: mmwave_beam_control_beam_selector
  parameters:
    debug: 'True'
    kpi_file: '"/home/user/sel_kpi_" + file_suffix + ".log"'
    pair_file: '"/home/user/sel_pair_" + file_suffix + ".log"'
    threshold: '0.0'
  states: {}
- name: mmwave_beam_control_beam_sweep_0
  id: mmwave_beam_control_beam_sweep
  parameters:
    beam_period: beam
    debug: 'True'
    ia_interval: iadr
    rx_iterable: rx_beams
    standalone: 'False'
    tx_iterable: tx_beams
  states: {}
- name: mmwave_beam_control_kpi_agg_0
  id: mmwave_beam_control_kpi_agg
  parameters:
    beam_file: '"/home/user/kpi_beam_" + file_suffix + ".log"'
    debug: 'True'
    meas_file: '"/home/user/kpi_meas_" + file_suffix + ".log"'
    meas_period: meas_period
    sensitivity: '-90.0'
    standalone: 'False'
    type: float
  states: {}
- name: mmwave_beam_control_rate_measure_0
  id: mmwave_beam_control_rate_measure
  parameters:
    debug: 'False'
    meas_file: '"/home/user/rate_meas_" + file_suffix + ".log"'
    meas_period: '1e-3'
  states: {}
- name: mmwave_beam_control_rss_calc_0_0
  id: mmwave_beam_control_rss_calc
  parameters:
    length: '1000'
    max_iter: '4000'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: CCI Software-defined mmWave Platform
    num_tabs: '1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*2
    fc: center_freq
    fftsize: '1024'
    gui_hint: 'qtgui_tab_widget_0@0 : 4,0,20,2'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '0.5'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: 2e6
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    type: eng_float
    value: '0.700'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 0.5*samp_rate
    center_freq0: center_freq
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: ''
    norm_gain0: 'True'
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: 0.5*samp_rate
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sd_spec0: B:0
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [digital_ofdm_rx_0, '0', mmwave_beam_control_rate_measure_0, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [mmwave_beam_control_beam_mapper_0, gpio_cmd, uhd_usrp_sink_0_0, command]
- [mmwave_beam_control_beam_selector_0, sweep, mmwave_beam_control_beam_sweep_0, sweep]
- [mmwave_beam_control_beam_sweep_0, beam_id, mmwave_beam_control_beam_mapper_0, beam_id]
- [mmwave_beam_control_beam_sweep_0, beam_id, mmwave_beam_control_kpi_agg_0, beam_id]
- [mmwave_beam_control_beam_sweep_0, trigger, mmwave_beam_control_beam_selector_0, trigger]
- [mmwave_beam_control_beam_sweep_0, trigger, mmwave_beam_control_kpi_agg_0, trigger]
- [mmwave_beam_control_beam_sweep_0, trigger, mmwave_beam_control_rate_measure_0, trigger]
- [mmwave_beam_control_kpi_agg_0, kpi_out, mmwave_beam_control_beam_selector_0, kpi_in]
- [mmwave_beam_control_rss_calc_0_0, '0', mmwave_beam_control_kpi_agg_0, '0']
- [uhd_usrp_source_0_0, '0', digital_ofdm_rx_0, '0']
- [uhd_usrp_source_0_0, '0', mmwave_beam_control_rss_calc_0_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
